# Repository MohamedBenabdelhadi/2425_ESE_Projet_V-NOM (continued)

## KiCad design Pojet_V-NOM_KiCAD/Pojet_V-NOM_KiCAD.kicad_pcb (continued)

Parts:
C1008: 15 pF; C_0402_1005Metric
C1009, C1010, C1012: 22 uF; C_0805_2012Metric
C1011, C1013, C1014: 0.1 uF; C_0402_1005Metric
IC1002: MP1475SGJ-P; SOT-23-8; Manufacturer_Part_Number MP1475SGJ-P; Mouser Part Number 946-MP1475SGJ-P
L1002: 4.7 uH; Inductance L1
R1007: 16 k; R_0402_1005Metric
R1008: 40.2 k; R_0402_1005Metric
R1009: 7.68 k; R_0402_1005Metric
R1010: 100 k; R_0402_1005Metric
R1011: 20; R_0402_1005Metric
R1012: 100k; R_0402_1005Metric
TP1001, TP1002, TP1003: TestPoint; TestPoint_Pad_D1.5mm

Connections:
+5V: C1008.1, C1009.1, C1012.1, L1002.1, R1008.1, TP1001.1; also elsewhere on the board
+BATT: C1010.2, C1011.2, IC1002.2 (IN), R1012.2, TP1002.1; also elsewhere on the board
GND: C1009.2, C1010.1, C1011.1, C1012.2, C1014.2, IC1002.4 (GND), R1009.2; also elsewhere on the board
unnamed: C1008.2, R1007.1, R1008.2, R1009.1
unnamed: C1013.1, R1011.2
unnamed: IC1002.5 (BST), R1011.1
unnamed: IC1002.6 (EN/SYNC), R1012.1
unnamed: IC1002.8 (FB), R1007.2
unnamed: IC1002.1 (PG), R1010.1
unnamed: C1013.2, IC1002.3 (SW), L1002.2
unnamed: C1014.1, IC1002.7 (VCC), R1010.2, TP1003.1

Notes on the sheet:
Régulateur 5V

Schematic: Régulateur_3.3V.kicad_sch

Parts:
C901, C902: 1uF; C_0603_1608Metric
PS901: BU33SD5WG-TR; SOT-23-5; Manufacturer_Part_Number BU33SD5WG-TR; Mouser Part Number 755-BU33SD5WG-TR
TP901: TestPoint; TestPoint_Pad_D1.5mm

Connections:
+3.3V: C902.1, PS901.5 (VOUT), TP901.1; also elsewhere on the board
+5V: C901.1, PS901.1 (VIN), PS901.3 (STBY); also elsewhere on the board
GND: C901.2, C902.2, PS901.2 (GND); also elsewhere on the board

Notes on the sheet:
Régulateur 3.3V

Board: 4 copper layers, 57.0 x 54.0 mm, 76 parts (0 on the bottom side), 53 nets.

## Code that names these connections

File Projet_V-NOM_STM32/Projet_V-NOM_STM32.ioc (part):

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Mcu.Name=STM32G431C(6-8-B)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32G431CBUx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=ToF2
PA0.Signal=SharedAnalog_PA0
PA10.Signal=S_TIM1_CH3
PA11.Signal=S_TIM4_CH1
PA12.Signal=S_TIM4_CH2
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=LIDAR_RX
PA15.Mode=Asynchronous
PA15.Signal=USART2_RX
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=AG_INT1
PA3.Signal=GPXTI3
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=AG_INT2
PA4.Signal=GPXTI4
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LED_RED
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=LED_GREEN
PB1.Signal=GPIO_Output
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=PWM Generation2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=LIDAR_TX
PB3.Mode=Asynchronous
PB3.Signal=USART2_TX
PB4.Signal=S_TIM3_CH1
PB5.Signal=S_TIM3_CH2
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=VCP_TX
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=VCP_RX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=BTN_MODE
PB9.Signal=GPIO_Input
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=EN_LIDAR
PC10.Signal=GPIO_Output
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=EN_MOT
PC11.Signal=GPIO_Output
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=BTN_START
PC13.Signal=GPIO_Input
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=SPI1_CSN
PC4.Signal=GPIO_Output
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=170000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-09-11 First BOM draft
    First BOM draft with the mandatory components.
2024-09-11 Mise à jour du README.md
2024-09-11 Mise à jour BOM
    Référence des composants fournis ajoutés avec des liens d'accès vers
    Farnell.
2024-09-11 BOM update
    Websites references for every mandatory component added.
2024-09-11 Documentation update
    Documentation of all mandatory components added.
2024-09-11 Documentation
2024-09-11 Choix du capteur de bords validé par l'enseignant
2024-09-11 Changement de la documentation du capteur de distance
2024-09-11 Driagramme d'architecture brouillon
2024-09-11 Référence du connecteur pour le capteur de bordure
2024-09-11 Diagramme d'architecture détaillé
2024-09-11 Small README.md fix
2024-09-11 Fix du diagramme d'architecture
2024-09-11 Améliorations du diagramme d'architecture
2024-09-18 Strategie détaillé sur README.md
2024-09-18 Mise à jour diagramme d'architecture
2024-09-18 Port pour capeur de distance ajouté au
2024-09-18 Empreinte du BU33SD5WG-TR
2024-09-18 Empreintes manquantes
    Ajout des empreintes :
    - BM03B-SRSS-TB_LFSN
    - MP1475SGJ-P
2024-09-18 Projet KiCAD vierge
2024-09-18 Création des branches par fonctionnalités
2024-09-18 Page alimentation créé
2024-09-18 Ajout de la bonne empreinte BU33SD5WG-TR
2024-09-18 Création de la page acquisition
2024-09-18 Création de la page controle
2024-09-18 Création de la page deplacement
2024-09-18 Création de la page interface_utilisateur
2024-09-18 Empreinte du STM32G431CBU6
2024-09-18 Update README.md
    Astuces git ajoutés
2024-09-18 Mise à jour du schéma éléctrique
2024-09-25 Mise à jour README.md
2024-09-25 Projet STM32CubeIDE
2024-09-25 Pins configurés projet STM32CubeIDE
2024-09-27 Schema Kicad ui
2024-09-30 Drivers
    schéma drivers
2024-09-30 Création .gitignore
2024-09-30 alimentation
    ajout alimentation
2024-09-30 Ajout de toutes les feuilles au projet principal
2024-09-30 Repositionnement des pins du up
2024-09-30 lidar
    rajout du lidar
2024-10-01 Update README.md
    orthographe
2024-10-01 pin
    update pin accel
2024-10-01 pin depla
    Maj. pin deplacement
2024-10-01 Fonctions Pins
2024-10-01 rajout capteur
    capteur de bordure
2024-10-01 regulateur 5 V
    Regulateur 5V maj
2024-10-01 MAJ Valerian
    MAJ Valerian
2024-10-01 Mise à jour des pins sur STM32CubeIDE
2024-10-01 Fichier lck ignoré
    Fichier lck de KiCAD igonré pour permettre la modification par tout le
    monde.
2024-10-01 Mise à jour des pins
2024-10-01 maj
    maj
2024-10-01 Mise à jour partie controle
2024-10-01 Import Pins UI
2024-10-01 .gitignore à jour
2024-10-01 Pins controle sortis
2024-10-01 Links UI première partie
2024-10-01 Revert "Links UI première partie"
    This reverts commit fbbc2c843fcae622b23db25f047c9362e448de8c.
2024-10-01 Recuperation UI
2024-10-01 Link Pins UI
    Les Pins qui ne sont pas encore liés n'ont pas de pins correspondants
    sur la partie controle. Il faut les créer (les deux leds rouge/verte) et
    demander au prof pour NRST et SWO
2024-10-01 DEPLACEMENT
    maj Deplacement
2024-10-01 Nouveau .gitignore pour les fichiers KiCAD
2024-10-01 Maj Deplacement
    Maj Deplacement
2024-10-01 modif_alim
    modif_alim
2024-10-01 Directions des liaisons UI
2024-10-01 modif
    modif
2024-10-01 modif
2024-10-01 Schéma de contrôle mis à jour
2024-10-01 .gitignore mis à jour pour éviter les conflits
2024-10-01 Mise à jour du schéma KiCAD
2024-10-01 Mise à jour du schéma de contrôle
2024-10-01 Mise à jour du schéma principal
2024-10-01 Maj
    Maj lidar et regualteur
2024-10-01 Retouches lisibilité Alim / capteurs
2024-10-01 Completion de l'attribution des pins
2024-10-02 maj des 3.3V et 5V
2024-10-02 Correction schéma accéléromètre
2024-10-02 Ajout des pin d'interruption AG
2024-10-02 Ajout des pin d'interruption 1 et 2 pour le AG sur STM32CubeIDE
2024-10-02 Branchement final de l'accéléromètre
2024-10-02 Fix Librairie STM32G410CBU6 mode project
2024-10-02 maj regulateur 5V
2024-10-02 Corrections rapides du schéma global
2024-10-02 Corrections sonde et switch
2024-10-02 Correction du schéma global
2024-10-02 DERNIER MODIF Alim
2024-10-02 Empreinte des bouttons poussoirs
2024-10-02 Fix boutons poussoirs + BTN_START
2024-10-02 bckp
2024-10-02 Empreinte boutons
2024-10-02 Modifications conseillés par l'enseignant
2024-10-02 Documents de cours ajoutés
2024-10-02 Nettoyage des librairies d'empreintes
2024-10-02 empreinte
2024-10-03 Correction des erreurs évidentes
    Changements avant vérification des erreurs :
    - Désallocation du pin BTN_RESET
    - Réarrangement de certaines sources pour cohérence avec tous les
    schémas éléctriques
2024-10-05 point de test et début de placement
2024-10-07 maj emplacement
2024-10-07 placement des compo dans la pcb
2024-10-08 maj placement
2024-10-08 Import de librairie YDLidar tiers
    Import de la librairie YDLidar développée dans le projet
    "stm32-ydlidar-x4".
    Plus d'informations sur le README.md
2024-10-08 placement maj
2024-10-08 maj deplacement
2024-10-08 routage
2024-10-09 Nouvelle empreinte ajouté
    Empreinte de l'inductance 4.7 μH 74404052047 - Würth Elektronik
2024-10-09 grande partie de routage
2024-10-11 maj routage
2024-10-16 retouche routage
2024-10-16 création schématique inductance
2024-10-16 Completion des feuilles de commande
2024-10-16 Feuille de commande finale
    Feuille de commande nécessaire finale retenue complétée.
2024-10-16 maj routage 24
2024-10-21 Maj final rootage + logo
2024-10-22 Add files via upload
    Datasheets des leds
2024-10-22 Update README.md BOM
2024-10-22 maj final aprés correction du prof + logo ensea
2024-10-23 Logo V-NOM
2024-10-23 Logo police V-NOM en png
2024-10-23 Modif
    dernier_Modification
2024-10-23 Create File fabrication
2024-10-23 fichier gbr
2024-10-23 final
2024-10-23 Mise à jour STM32CubeIDE
    - Mise à jour des pins attribués aux capteurs ToF pour.
    - Ajout du driver du GP2Y0A41SK0F.
2024-11-20 Projet test STM32CubeIDE pour YLIDAR
2024-11-20 Datasheet YLIDAR X2
    Nous avons à disposition le YLIDAR X2 pour nos essais.
2024-11-27 Mecanique et interpretation du YLIDAR2
2024-11-27 YLIDAR2 fixes
2024-12-04 YLIDAR X2 parsing working
2024-12-04 YLIDAR parsing fixed
2024-12-10 controle_moteur_capteur
2024-12-11 ADXL driver
2024-12-11 YLIDARX2 Driver v1 completed
2024-12-11 Drivers standardised
2024-12-17 Starting Message & ADXL driver moved
2024-12-17 YLIDARX2 driver updated & Main modified for tests
2024-12-17 Refactor Motor drivers
2024-12-17 Motor drivers standardised
2024-12-18 Motors driver updated
2024-12-18 Motor driver header updated
2024-12-18 Motors driver tested
2024-12-18 ToF tests
2024-12-18 ToF sensors tested
2024-12-18 ToF driver fixed & README.md updated
2024-12-21 ADXL343 testing
2024-12-22 SPI connection fixed: data size set to 8 bits
2024-12-22 Overwriting driver for ADXL343
2024-12-22 Driver ADXL343
2024-12-22 Final naive drivers for ADXL343
    This new driver is naive since it doesn't handle power saving or data format configuration. It only configures the ADXL343 to expect 4g variations and read the acceleration data.
2025-01-03 YDLIDAR SDK Added
2025-01-03 YDLIDAR SDK installed, New YLidar X2 driver
2025-01-07 New YLidarX2 driver
2025-01-07 New YLidarX2 driver implemented to main project
2025-01-07 Noise Error with the UART2 communication
2025-01-07 UART2: Framing Error
2025-01-08 YDLidar SDK removed
2025-01-09 Input Frequency for HSE modified to 16 MHz
2025-01-09 Update README.md
    Quick formatting
2025-01-09 Trial fixes
2025-01-09 Demo algorithm
2025-01-10 FoT sensors interrupt
    ToF sensors DMA removed
2025-01-10 ADXL343 Single Tap Interrupt
2025-01-10 main.c optimization
2025-01-10 Doxygen comments added
2025-01-10 USART2 DMA priority Very High
2025-01-10 Doxygen documentation
2025-01-10 Create Doxyfile
2025-01-10 Update main.c
    Stop on start button pressed
2025-01-10 Doxygen Updated
2025-01-10 ADC IRQ issue
2025-01-10 ToF sensors in polling mode
2025-01-10 Quick fix
2025-01-12 Support des Capteurs
2025-01-14 YLidar X2 DMA driver
2025-01-14 Revert "YLidar X2 DMA driver"
    This reverts commit edcbfe3d9d525ab5c18b018b1decbfc4f346268b.
2025-01-14 Final algorithm verification
2025-01-15 New Doxygen doc
2025-01-15 Docs update
2025-01-15 Final HTML doc from Doxygen
